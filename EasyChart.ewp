# IAR project EasyChart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030; STM32_SD_USE_DMA
  ICCARM.CCIncludePath2: CMSIS/; SPL/; ; fatfs/; utils/
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: EasyChart.hex
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: STM32F030R8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    fatfs/: buttons.c buttons.h dmaread.c
    Fonts/: DefaultFonts.c
    ./: hardware.h lcd.cpp lcd.h main.cpp main.h myf.cpp myf.h periph.c periph.h Projection.cpp Projection.h stm32f0xx_conf.h timecrit.s wintypes.h
    ../../C/: main.ENU.projtempl
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cmFunc.h core_cmInstr.h startup_stm32f030.s stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group fatfs
    fatfs/: diskio.h fattime.c fattime.h ff.c ff.h ffconf.h integer.h sd_spi_driver_stm32f0.c
  group Pictures
    Sprites/: up.c
  group SPL
    SPL/: stm32f0xx_crc.c stm32f0xx_crc.h stm32f0xx_dbgmcu.c stm32f0xx_dbgmcu.h stm32f0xx_dma.c stm32f0xx_dma.h stm32f0xx_exti.c stm32f0xx_exti.h stm32f0xx_gpio.c stm32f0xx_gpio.h stm32f0xx_misc.c stm32f0xx_misc.h stm32f0xx_rcc.c stm32f0xx_rcc.h stm32f0xx_spi.c stm32f0xx_spi.h stm32f0xx_syscfg.c stm32f0xx_syscfg.h stm32f0xx_tim.c stm32f0xx_tim.h stm32f0xx_usart.c stm32f0xx_usart.h
  group utils
    utils/: gpioex.c gpioex.h Timing.c Timing.h utils.c utils.h
